# libeigen is a template library, ie, source-only.
ALLOW_EMPTY_${PN} = "1"
