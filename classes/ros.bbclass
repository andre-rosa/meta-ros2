# ros.bbclass
inherit ros_common

# Place any other metadata unique to ROS here.
