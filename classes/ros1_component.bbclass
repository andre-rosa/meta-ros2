inherit ros_component

# Place metadata unique to components of type "ros1" here.
