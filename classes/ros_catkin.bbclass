# ros_catkin.bbclass
inherit catkin.bbclass
