# ros_bouncy.bbclass

ROS_DISTRO_EDITION = "ros2"
export ROS_DISTRO_VERSION = "2"

inherit ${ROS_DISTRO_EDITION}
