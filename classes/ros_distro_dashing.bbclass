# Copyright (c) 2019 LG Electronics, Inc.

inherit ${ROS_DISTRO_TYPE}_distro
