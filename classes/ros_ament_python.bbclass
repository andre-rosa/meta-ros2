# ros_ament_python.bbclass

inherit ament-python
