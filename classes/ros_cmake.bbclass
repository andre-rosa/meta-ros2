# ros_cmake.bbclass

inherit cmake
