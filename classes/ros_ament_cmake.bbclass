# ros_ament_cmake.bbclass

inherit ament
