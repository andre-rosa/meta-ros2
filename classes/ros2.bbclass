# ros2.bbclass

inherit ros_common

ROS_USE_PYTHON3 = "yes"
# Place any other metadata unique to ROS 2 here.
