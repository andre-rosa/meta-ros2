PROVIDES += "python3-pkg-resources"
PROVIDES_append_class-native = " python3-pkg-resources-native"

RPROVIDES_${PN} += "python3-pkg-resources"
RPROVIDES_${PN}_append_class-native = " python3-pkg-resources-native"
