require python-nose-yanc.inc

inherit setuptools3
