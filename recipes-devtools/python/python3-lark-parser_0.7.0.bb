require python-lark-parser.inc

inherit setuptools3
