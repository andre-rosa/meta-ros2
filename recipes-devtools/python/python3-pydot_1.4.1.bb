require python-pydot.inc

inherit distutils3
