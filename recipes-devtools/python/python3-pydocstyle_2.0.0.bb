require python-pydocstyle.inc

inherit setuptools3
