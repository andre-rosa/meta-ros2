require python-sphinx.inc

inherit setuptools3
