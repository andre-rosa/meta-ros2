PROVIDES_append = " python3-dev-native"
# python3-native is special: no _${PN}
RPROVIDES_append = " python3-dev-native"
