# Add (r)provides for libdw-dev
PROVIDES += " libdw-dev"
RPROVIDES_${PN} += " libdw-dev"
RPROVIDES_${PN}-class_native += " libdw-dev-native"
