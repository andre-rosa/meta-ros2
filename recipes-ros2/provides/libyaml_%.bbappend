PROVIDES += "libyaml-vendor"
RPROVIDES_${PN} += "libyaml-vendor"
